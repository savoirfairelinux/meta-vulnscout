IMPROVE_KERNEL_PREFERRED_PROVIDER = "create-spdx-3.0"
IMPROVE_KERNEL_SPDX_FILE = "${SPDXIMAGEDEPLOYDIR}/${IMAGE_LINK_NAME}.spdx.json"

inherit improve_kernel_cve_report-base