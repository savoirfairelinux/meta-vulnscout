inherit vulnscout

# Optional: add improve_kernel_cve_report class to generate improved CVE reports for the kernel
inherit improve_kernel_cve_report
