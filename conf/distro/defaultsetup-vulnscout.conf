## conf/distro/defaultsetup-vulnscout.conf
```bitbake
require conf/distro/defaultsetup.conf
require conf/distro/include/sbom-cve-check.inc
require conf/distro/include/vulnscout-core.inc
```
